require libcups.inc

CUPS_SYSCONFDIR = "/etc"

LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "a3fec6e70ba34fa41316e687e37ab9a2"
SRC_URI[sha256sum] = "80df9125c6af777b0275568e5c4a33e1ffaedf50969a4cef6f9195006ca23c34"
