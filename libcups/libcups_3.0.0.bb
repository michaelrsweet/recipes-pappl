require libcups.inc

CUPS_SYSCONFDIR = "/etc"

LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "13d92456de78acc76e0bd9b56e318b2d"
SRC_URI[sha256sum] = "62bd79f477e0dd9d3a93ede19e514f60b55cb4fe19e4b25158b1fa7be2269dbf"
