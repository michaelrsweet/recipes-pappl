require pappl.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "84d4614028792cf6072112de2e6b86ed"
SRC_URI[sha256sum] = "d4322244093e6db8268cd1157219a017b530032b6c32fb803efc8278ac639d98"
